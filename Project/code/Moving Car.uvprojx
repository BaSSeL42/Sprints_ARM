# Keil uVision project Moving Car.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Moving Car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APP\includes;.\COM;.\HAL\button\include;.\HAL\led\include;.\HAL\motor;.\MANAER\car_control;.\MCAL\DIO;.\MCAL\EXIT;.\MCAL\gpt\include;.\MCAL\NVIC;.\MCAL\SYS_CONTROL;.\SERVICE\timer_management\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./APP/: app.c
    ./APP/includes/: app.h
    ./COM/: std_types.h bit_math.h
    ./HAL/button/: button.c
    ./HAL/button/include/: button.h
    ./HAL/led/: led.c
    ./HAL/led/include/: led.h
    ./HAL/motor/: motor.c motor_conf.h motor_config.c motor_interface.h
    ./MANAER/car_control/: car_control.c car_control_interface.h
    ./SERVICE/timer_management/: timerM_Program.c
    ./SERVICE/timer_management/include/: timerM_Interface.h
    ./MCAL/DIO/: DIO_interface.h DIO_private.h DIO_prog.c
    ./MCAL/EXIT/: EXIT_config.h EXIT_interface.h EXIT_private.h EXIT_prog.c
    ./MCAL/gpt/: gpt_source.c
    ./MCAL/gpt/include/: gpt_Config.h gpt_Interface.h gpt_Private.h
    ./MCAL/NVIC/: NVIC_interface.h NVIC_private.h NVIC_prog.c
    ./MCAL/SYS_CONTROL/: SYS_CONTROL_interface.h SYS_CONTROL_private.h SYS_CONTROL_prog.c
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
