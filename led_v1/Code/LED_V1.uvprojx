# Keil uVision project LED_V1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_V1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MCAL\mgpio\includes;.\HAL\LED\include;.\HAL\Button\include;.\APP\includes;.\COM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./MCAL/mgpio/: mgpio_Program.c
    ./MCAL/mgpio/includes/: mgpio_Config.h mgpio_Interface.h mgpio_Private.h
    ./: main.c
    ./HAL/LED/: led.c
    ./HAL/LED/include/: led.h
    ./HAL/Button/: button.c
    ./HAL/Button/include/: button.h
    ./COM/: LSTD_TYPES.h LBIT_MATH.h
    ./APP/: app.c
    ./APP/includes/: app.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
