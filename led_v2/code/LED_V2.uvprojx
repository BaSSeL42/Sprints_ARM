# Keil uVision project LED_V2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123BH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_V2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\code\MCAL\systick\include;..\code\MCAL\MGPIO\includes;..\code\COM;..\code\HAL\LED\include;..\code\HAL\Button\include;..\code\APP\includes;.\HAL\systick_manager\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../code/: main.c
    ../code/MCAL/systick/: systick_source.c
    ../code/MCAL/systick/include/: systick_Interface.h systick_Private.h
    ../code/MCAL/MGPIO/: mgpio_Program.c
    ../code/MCAL/MGPIO/includes/: mgpio_Config.h mgpio_Interface.h
    ./MCAL/MGPIO/includes/: mgpio_Private.h
    ./HAL/LED/: led.c
    ./HAL/LED/include/: led.h
    ./HAL/Button/: button.c
    ./HAL/Button/include/: button.h
    ./COM/: LBIT_MATH.h LSTD_TYPES.h
    ./APP/: app.c
    ./APP/includes/: app.h
    ./HAL/systick_manager/: systick_manager.c
    ./HAL/systick_manager/include/: systick_manager.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
