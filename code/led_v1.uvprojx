# Keil uVision project led_v1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_v1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\COM;.\MCAL\MGPIO\includes;.\HAL\Button\include;.\HAL\LED\include;.\APP\includes;.\MCAL\wdt\include;.\MCAL\systick\include;.\MCAL\gpt\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
    ./APP/: app.c
    ./APP/includes/: app.h
  group MCAL
    ./MCAL/MGPIO/: mgpio_Program.c
    ./MCAL/MGPIO/includes/: mgpio_Config.h mgpio_Interface.h mgpio_Private.h
    ./MCAL/wdt/include/: wdt_Interface.h wdt_private.h
    ./MCAL/wdt/: wdt_source.c
    ./MCAL/systick/: systick_source.c
    ./MCAL/systick/include/: systick_Interface.h systick_Private.h
    ./MCAL/gpt/: gpt_source.c
    ./MCAL/gpt/include/: gpt_Interface.h gpt_Private.h gpt_Config.h
  group COM
    ./COM/: LBIT_MATH.h LSTD_TYPES.h
  group HAL
    ./HAL/LED/: led.c
    ./HAL/Button/: button.c
    ./HAL/Button/include/: button.h
    ./HAL/LED/include/: led.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
