# Keil uVision project LED_V3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_V3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\code\APP\includes;.\code\COM;.\code\HAL\Button\include;.\code\HAL\LED\include;.\code\HAL\gpt_manager\include;.\code\MCAL\MGPIO\includes;.\code\MCAL\gpt\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./code/: main.c
    ./code/MCAL/MGPIO/: mgpio_Program.c
    ./code/MCAL/MGPIO/includes/: mgpio_Config.h mgpio_Interface.h mgpio_Private.h
    ./code/MCAL/gpt/: gpt_source.c
    ./code/MCAL/gpt/include/: gpt_Config.h gpt_Interface.h gpt_Private.h
    ./code/HAL/LED/: led.c
    ./code/HAL/LED/include/: led.h
    ./code/HAL/Button/: button.c
    ./code/HAL/Button/include/: button.h
    ./code/COM/: LBIT_MATH.h LSTD_TYPES.h
    ./code/APP/: app.c
    ./code/APP/includes/: app.h
    ./code/HAL/gpt_manager/: gpt_manager.c
    ./code/HAL/gpt_manager/include/: gpt_manager.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
